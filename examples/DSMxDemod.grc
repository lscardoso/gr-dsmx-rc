options:
  parameters:
    generate_options: qt_gui
    id: top_block
    max_nouts: '00'
    output_language: python
  states: {}

blocks:
- name: channel
  id: variable_qtgui_range
  parameters:
    min_len: '1'
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '13'
  states: {}
- name: f_deviation
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    min_len: '1000000'
    start: 2.4e9
    step: 1e6
    stop: 2.5e9
    value: 2.405e9
  states: {state: disabled}
- name: intermediate_samp_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(intermediate_samp_rate/1e6)
  states: {}
- name: top_block_fournisseur
  id: variable_function_probe
  parameters:
    block_id: chan_change
    function_name: set_top_block
    poll_rate: '1'
    value: '0'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-50'
    type: complex
  states: {state: bypassed}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.2e6
    low_cutoff_freq: 0.1e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: chan_change
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import inspect
      from gnuradio import gr
      import pmt
      import tkinter.ttk as tk
      import os, struct, array
      from fcntl import ioctl
      import sys, tty, termios
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Controller block:
      Recieves decoded data, prints it, follows the channel sequence and sweeps channels 3 to 11 when no signal is detected."""

          def __init__(self, param=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Channel Changer',   # will show up in GRC
                  in_sig=[],
                  out_sig = []
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern("ChannelChange"))
              self.set_msg_handler(pmt.intern("ChannelChange"), self.chanChangeCallback)
              self.top_block = param
              self.channel_data = np.zeros((2,7))
              self.startup = True
              self.next_channel = 3


              """Called when a decoded packet is recieved"""
          def chanChangeCallback(self, msg):
              string = ''
              meta = pmt.car(msg) #Extract the metadata
              self.next_channel = pmt.to_python(pmt.dict_ref(meta,pmt.intern("Next channel"),pmt.PMT_NIL))
              self.top_block.set_channel(self.next_channel)   #This call should be done as soon as possible to avoid issues with channel switch delays

              radio_id1 = pmt.to_python(pmt.dict_ref(meta,pmt.intern("Radio id1"),pmt.PMT_NIL))
              radio_id1 = pmt.to_python(pmt.dict_ref(meta,pmt.intern("Radio id1"),pmt.PMT_NIL))
              data = pmt.cdr(msg)         #Data should contain a 23 byte array with the channel sequence to follow.
              if not pmt.is_u8vector(data):
                  print('Invalid message type')
                  return
              for item in pmt.to_python(data):
                  string = string + str(item) + ' '               #update GUI
                  self.window.detectedLabel.config(text = string)
              string = ''
              for i in range(0,7):
                  tmp = pmt.to_python(pmt.dict_ref(meta,pmt.intern("0 "+str(i)),pmt.PMT_NIL))
                  if tmp:
                      self.channel_data[0][i] = tmp
                  tmp = pmt.to_python(pmt.dict_ref(meta,pmt.intern("1 "+str(i)),pmt.PMT_NIL))     #Extract data coming from a potential 2nd packed (if more than 7 channels are being transmitted) unused
                  if tmp:
                      self.channel_data[1][i] = tmp
                  string = string + "CH" + str(i) + ": " + '{:03.2f}'.format((self.channel_data[0][i]/1024.0) -1) + " | "
              self.window.channelInfoLabel.config(text = string)      #update GUI
              self.has_detected_signal = True

          """Called once a second"""
          def set_top_block(self):
              prev_frame = inspect.currentframe().f_back
              block = prev_frame.f_locals["self"]
              if self.startup:                    #Inititalize. If done in the __init__ function, GRC will try to call it before runtime and will crash (or do something bad) GRC does not like treads and don't know top_block
                  self.has_detected_signal = True
                  self.top_block = block
                  self.startup = False
                  def launchWindow():                 #Setup GUI
                      self.window = ui(self)
                      self.window.master.title('DSMx Decoder')
                      self.window.mainloop()
                  self._window_thread = threading.Thread(target=launchWindow)
                  self._window_thread.daemon = True
                  self._window_thread.start()

              if not self.has_detected_signal:
                  print('No signal found in 1s, changing channel')
                  self.next_channel = self.sweep_channel(self.next_channel)
                  self.window.detectedLabel.config(text = "Sweeping.")
                  self.window.channelInfoLabel.config(text = "Current channel: "+str(self.next_channel))
                  self.top_block.set_channel(self.next_channel)
              self.has_detected_signal = False

          def sweep_channel(self, current):
              current = current + 1
              if current > 11:
                  current = 3
              return current

          def work(self, input_items, output_items): #Useless
              return len(input_items[0])



      class ui(tk.Frame):
          def __init__(self, calling, master=None):
              tk.Frame.__init__(self, master)
              self.config(height = 100, width = 1500)
              self.grid()
              self.createWidgets()
              self.calling = calling

          def createWidgets(self):
              self.freqLabel = tk.Label()
              self.freqLabel.grid()
              self.detectedLabel = tk.Label(text=" ")
              self.detectedLabel.grid()
              self.channelInfoLabel = tk.Label(text=" No signal found..  ")
              self.channelInfoLabel.grid()
              self.freqLabel.bind_all('<KeyPress-Return>', self._enterHandler)        #Unused but useful in case of user interaction
              self.freqLabel.bind_all('<KeyPress-Escape>', self._escapeHandler)

          def _enterHandler(self,event):
              self.calling.input_key = 'enter'
          def _escapeHandler(self,event):
              self.calling.input_key = 'escape'
    param: '1'
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: '1'
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1100110011001100110011001100110011001100110011001100110011001100'
    tagname: PreambleFound
    threshold: '8'
    type: byte
  states: {}
- name: dsmx_Despreader_0
  id: dsmx_Despreader
  parameters: {}
  states: {}
- name: dsmx_bindListener_0
  id: dsmx_bindListener
  parameters: {}
  states: {state: disabled}
- name: dsmx_preambleDetection_0
  id: dsmx_preambleDetection
  parameters:
    channel: channel
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.3e6
    decim: '1'
    gain: '1'
    samp_rate: intermediate_samp_rate
    type: fir_filter_ccf
    width: 500e3
    win: window.WIN_BLACKMAN
  states: {state: bypassed}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: int(12240.0*((float(intermediate_samp_rate)/1e6)/8.0))
    srate: intermediate_samp_rate
    tr_delay: '0.0001'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: int(12240.0*sps/8.0)
    srate: samp_rate
    tr_level: '1.5'
    tr_tag: '"Found"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    nconnections: '2'
    size: '12000'
    srate: 1e6
    tr_delay: '.0001'
    tr_level: '1.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"PreambleFound"'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: ((channel+1) * 1e6) + 2.4e9
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '1'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_1, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_1, '0', digital_clock_recovery_mm_xx_1, '0']
- [analog_quadrature_demod_cf_1, '0', qtgui_time_sink_x_1_0, '0']
- [band_pass_filter_0, '0', low_pass_filter_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_1_1, '0']
- [digital_binary_slicer_fb_1, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_clock_recovery_mm_xx_1, '0', digital_binary_slicer_fb_1, '0']
- [digital_clock_recovery_mm_xx_1, '0', qtgui_time_sink_x_1_1, '1']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', dsmx_preambleDetection_0, '0']
- [dsmx_Despreader_0, pdus, chan_change, ChannelChange]
- [dsmx_preambleDetection_0, pdus, dsmx_Despreader_0, Msg]
- [dsmx_preambleDetection_0, pdus, dsmx_bindListener_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-91-gb554eeab
